# Keil uVision project atk_f103.uvprojx, settings and files
target TOUCH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares;..\..\Drivers\BSP\NET\device;..\..\Drivers\BSP\NET\MQTT;..\..\Drivers\BSP\NET\onenet;..\..\Drivers\BSP\USART;..\..\Drivers\BSP\NET\cJSON
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/TOUCH/: ctiic.c gt9xxx.c touch.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/ADC_DMA/: my_adc.c
    ../../Drivers/BSP/DAC/: dac.c
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/DHT11/: dht11.c
    ../../Drivers/BSP/SERVO/: servo.c
    ../../Drivers/BSP/MOTOR/: motor.c
    ../../Drivers/BSP/B_TIMER/: btim.c
    ../../Drivers/BSP/KEY_EXTI/: key_exti.c
    ../../Drivers/BSP/GTIM/: gtim.c
    ../../Drivers/BSP/USART/: usart.c
    ../../Drivers/BSP/NET/device/: esp8266.c
    ../../Drivers/BSP/NET/MQTT/: MqttKit.c
    ../../Drivers/BSP/NET/onenet/: onenet.c
    ../../Drivers/BSP/NET/cJSON/: cJSON.c
    ../../Drivers/BSP/STEPPING_MOTOR/: stepping_motor.c
    ../../Drivers/BSP/RTC/: rtc.c
  group Readme
    ../../: readme.txt
