# Keil uVision project BLDC_Sensorless_FOC.uvprojx, settings and files
target TLE9879_EvalKit (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TLE9871QXA20 Infineon
  pack: Infineon.TLE987x_DFP.1.4.8
  cpu: IRAM(0x18000018,0xBE8) IRAM2(0x18000000,0x10) IROM(0x11000000,0x7FFC) IROM2(0x11007FFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 110WPump +hex
  c flags: Optim=3 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\app;.\emo;.\Simulink\AppMain_ert_rtw
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x7fe8
  memory RVCT5: ROM 0x11007fe8 size 0x18
  memory RVCT9: RAM 0x18000018 size 0xbe8
  memory RVCT10: RAM 0x18000000 size 0x10
  link misc: --diag_suppress L6918
  group App
    ./app/: Main.c common.c testmode.c userinfo.c PwmIn.c ADCSample.c MotorAPI.c SDK.c DTC.c FanComTest.c GlobalVars.c IsrHandler.c
  group Emo
    ./emo/: Emo.c Emo_cfg.c Emo_RAM.c Table.c
  group Simulink
    ./Simulink/AppMain_ert_rtw/: AppMain.c AppMain_data.c ECUFaultDiag.c FeedBack.c MotorRestartAndFaultCnt.c MotorTargetSpeedMux.c PwmInParamEval.c PwmInTargetSpeedEval.c rt_sys_ECUFaultDiag_0.c
software components: CMSIS:CORE 5.4.0, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.2.7, Device:SDK:ADC2 0.2.3, Device:SDK:BDRV 0.4.5, Device:SDK:BOOTROM 0.3.0, Device:SDK:CCU6 0.3.2, Device:SDK:CSA 0.1.6, Device:SDK:DMA 0.2.0, Device:SDK:GPT12E 0.2.0, Device:SDK:INT 0.2.2, Device:SDK:ISR 0.2.8, Device:SDK:LIN 0.1.9, Device:SDK:MON 0.1.6, Device:SDK:PMU 0.2.0, Device:SDK:PORT 0.5.7, Device:SDK:SCU 0.4.1, Device:SDK:SSC 0.1.7, Device:SDK:TIMER2x 0.2.0, Device:SDK:TIMER3 0.1.7, Device:SDK:UART 0.2.2, Device:SDK:WDT1 0.3.1, Device:Startup 1.1.0
