# IAR project T36-18.ewp, settings and files
configuration 52301 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430dn.h
  General.OGChipSelectMenu: MSP430_EL_M52399B EL_M52399B
  General.GStackSize2: 512
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: T52301; NOMENU
  ICC430.newCCIncludePaths: api\inc; inc
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkEL_M52399A.xcl
  XLINK.XlinkStackSize: 1
configuration 52350 (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: T52350; NOMENU
  ICC430.newCCIncludePaths: api\inc; inc; source\SciDebug; Simulink\AppMain_ert_rtw; source\FreeMaster\src_common; source\FreeMaster\src_platforms\elmos_52352
  ICC430.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkEL_M52399B.xcl
  group (top)
    source/: ADCSample.c bemf_control.c commons.c crcccitt.c debug.c driver_52350.c driver_generic.c DTC.c IsrHandler.c main.c motor.c MotorAPI.c parameters.c pi_controller.c pre_pwm_helper_addon.c pre_pwm_module.c pre_pwm_tables.c pwm_module.c PwmIn.c saradc_module.c saradc_tables.c u_f_table.c VBatMonitor.c
    inc/: parameters.h pi_controller.h version.h
  group api
    api/: cctimer.c crc16.c divider.c flash_ctrl.c gpio.c h430_mul.c iomux_ctrl.c mem_prot.c pre_pwm.c pre_pwm_helper.c pwmn.c saradc_ctrl.c sci.c spi.c sys_state.c utils.c vic.c wdog.c
  group FreeMaster
    source/FreeMaster/src_common/: freemaster_appcmd.c freemaster_pipes.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c
    source/FreeMaster/src_platforms/elmos_52352/: freemaster_e52352.c
  group SCIDebug
    source/SciDebug/: testmode.c uartdebug.c
  group Simulink
    Simulink/AppMain_ert_rtw/: AppMain.c AppMain_data.c ECUFaultDiag.c FeedBack.c MotorRestartAndFaultCnt.c MotorTargetSpeedMux.c PwmInParamEval.c PwmInTargetSpeedEval.c rt_sys_ECUFaultDiag_0.c
